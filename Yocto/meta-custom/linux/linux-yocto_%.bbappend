FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-i2c1-dts.patch"
