FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://beaglebone_defconfig"